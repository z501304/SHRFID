# Keil uVision project ReturnBook_v2_10.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(33000000) MODAT2
  output: ReturnBook_Librarian_20230603-A +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 communication.c equipment.c hf_reader.c main.C system_initiate.c
